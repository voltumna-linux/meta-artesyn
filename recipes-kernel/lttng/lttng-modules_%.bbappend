EXTRA_OEMAKE_append_mvme2500 = " HAS_BIARCH=n"
