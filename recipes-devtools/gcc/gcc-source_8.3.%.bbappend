FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += " \
	file://0001-Revert-PR-target-81084.patch \
	"
